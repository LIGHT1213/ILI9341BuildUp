# Keil uVision project ILI9341BuildUp.uvprojx, settings and files
target ILI9341BuildUp (6140001::V6.14.1::ARMCLANG)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF)   CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: ILI9341BuildUp +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx
  c include: ../Core/Inc;                 ../Drivers/STM32H7xx_HAL_Driver/Inc;                 ../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;                 ../Drivers/CMSIS/Device/ST/STM32H7xx/Include;                 ../Drivers/CMSIS/Include;                 ..\ILI9341
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c tim.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group ILI9341Driver
    ../ILI9341/: ILI9341Driver.h ILI9341DriverWrapper.h ILI9341DriverWrapper.cpp ILI9341Driver.cpp
software components: CMSIS:CORE 5.4.0
